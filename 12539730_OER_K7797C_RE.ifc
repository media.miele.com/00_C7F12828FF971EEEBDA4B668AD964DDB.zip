Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: c95b04db-e137-4323-91c2-003d057ff9b2, NumberOfSaves: 1]
File name: 0001
Time: 2024-03-28T10:04:38+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12539730_OER_K7797C_RE:36779700_OER_12539730_K7797C_RE, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Design_BRWS, <Unnamed>, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_Glass, z_Miele_Connection_Electric
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: 36779700_OER_12539730_K7797C_RE; sets with these values: 2

# IfcDistributionPort, Port_354281_1
Description: Flow; FlowDirection: SOURCEANDSINK
